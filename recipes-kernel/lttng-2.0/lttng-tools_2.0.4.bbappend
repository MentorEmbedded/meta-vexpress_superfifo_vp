PRINC := "${@int(PRINC) + 1}"
SRC_URI = "git://git.lttng.org/lttng-tools.git;protocol=git"
