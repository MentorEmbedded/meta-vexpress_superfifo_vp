FILESEXTRAPATHS_prepend_vexpress_superfifo_vp := "${THISDIR}/${PN}:"

